OBMC_IMAGE_EXTRA_INSTALL:append:my-xeon6 = " usb-ethernet-gadget"
IMAGE_FEATURES:append:my-xeon6 = " obmc-dbus-monitor"
