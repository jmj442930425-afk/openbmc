PACKAGECONFIG:append:my-xeon6 = " log-threshold log-watchdog send-to-logger log-alarm"
