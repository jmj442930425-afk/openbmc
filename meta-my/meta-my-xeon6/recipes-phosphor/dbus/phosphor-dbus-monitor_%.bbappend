FILESEXTRAPATHS:append:my-xeon6 := ":${THISDIR}/${PN}"
