PHOSPHOR_DBUS_MONITOR_CONFIGS:append:my-xeon6 = " chassis-intrusion-monitor"
